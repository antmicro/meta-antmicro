# add CUDA for OpenCV
inherit cuda
