inherit antmicro-jetson-base-image
