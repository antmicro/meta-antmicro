BBCLASSEXTEND = "native"
DEPENDS:remove:class-native = "libgfortran"
