BBCLASSEXTEND = "native"
DEPENDS_remove_class-native = "libgfortran"
