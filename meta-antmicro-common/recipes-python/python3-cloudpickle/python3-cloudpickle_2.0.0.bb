SUMMARY = "cloudpickle"
DESCRIPTION = "cloudpickle makes it possible to serialize Python constructs not supported by the default pickle module from the Python standard library."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b4d59aa5e2cc777722aac17841237931;"

SRC_URI[sha256sum] = "5cd02f3b417a783ba84a4ec3e290ff7929009fe51f6405423cfccfadd43ba4a4"
SRC_URI[md5sum] = "133a7fe80b773937498918d0715b56bf"

inherit pypi setuptools3
