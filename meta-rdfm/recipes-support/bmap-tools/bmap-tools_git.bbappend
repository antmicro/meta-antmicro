SRC_URI = "git://github.com/yoctoproject/bmaptool.git;branch=main;protocol=https"
