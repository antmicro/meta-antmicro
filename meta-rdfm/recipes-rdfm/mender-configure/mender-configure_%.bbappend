RDEPENDS:${PN}:remove = "mender-client"
RDEPENDS:${PN}:append = "rdfm-client"
