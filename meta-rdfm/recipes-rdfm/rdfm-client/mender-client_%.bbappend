FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI = "git://github.com/antmicro/rdfm;protocol=https;branch=master"

PTEST_ENABLED_riscv64 = "0"
