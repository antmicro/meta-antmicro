go_%.bbappend