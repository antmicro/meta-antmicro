EXTRA_IMAGECMD:btrfs:remove = "--shrink"
