INITSCRIPT_PARAMS = "disable"
