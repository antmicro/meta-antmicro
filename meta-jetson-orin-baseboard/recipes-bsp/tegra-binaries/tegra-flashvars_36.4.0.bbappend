TEGRA_FLASHVAR_MB2BCT_CFG:tegra234="tegra234-mb2-bct-misc-p3767-0000-antmicro-job.dts"
