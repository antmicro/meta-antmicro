FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += " \
    file://tegra234-mb2-bct-misc-p3767-0000-antmicro-job.dts \
    file://tegra264-mb2-bct-misc-p3834-xxxx-antmicro.dts \
    file://tegra234-mb2-bct-misc-p3701-0000-antmicro-job.dts \
    file://tegra234-mb2-bct-misc-p3701-0008-antmicro-job.dts \
"
