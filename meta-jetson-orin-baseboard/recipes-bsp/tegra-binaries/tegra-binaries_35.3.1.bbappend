FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += " file://tegra234-mb2-bct-misc-p3767-0000-antmicro-job.dts "
