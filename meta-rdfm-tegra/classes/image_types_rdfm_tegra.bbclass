inherit image_types_tegra

DATAFILE ?= "${IMAGE_BASENAME}-${MACHINE}.${RDFM_DATAFSIMG_EXT}"
IMAGE_TEGRAFLASH_DATA ?= "${IMGDEPLOYDIR}/${IMAGE_LINK_NAME}.${RDFM_DATAFSIMG_EXT}"
IMAGE_TEGRAFLASH_ROOTFS ?= "${IMGDEPLOYDIR}/${IMAGE_LINK_NAME}.${RDFM_ROOTFSIMG_EXT}"

# Influences the file name deployed and used by initrd-flash script
IMAGE_TYPEDEP:tegraflash:remove = "${IMAGE_TEGRAFLASH_FS_TYPE}"
IMAGE_TEGRAFLASH_FS_TYPE = "${RDFM_ROOTFSIMG_EXT}"
