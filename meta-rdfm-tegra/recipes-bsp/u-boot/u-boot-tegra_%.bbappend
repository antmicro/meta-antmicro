include ${@mender_feature_is_enabled("mender-uboot", "u-boot-rdfm.inc", "", d)}
