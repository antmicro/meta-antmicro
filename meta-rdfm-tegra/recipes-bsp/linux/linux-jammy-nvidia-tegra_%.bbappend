FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = "file://0001-drivers-timer-tegra186-Allow-modifying-default-timeo.patch"