BBCLASSEXTEND += "native"